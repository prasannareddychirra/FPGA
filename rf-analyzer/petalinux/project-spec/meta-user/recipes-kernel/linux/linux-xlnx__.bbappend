SRC_URI += "file://user_2020-06-22-09-47-00.cfg \
            file://user_2020-07-31-12-04-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

